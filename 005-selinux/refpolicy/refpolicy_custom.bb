DMYPV = "2.20170204"
SRC_URI = "https://raw.githubusercontent.com/wiki/TresysTechnology/refpolicy/files/refpolicy-${DMYPV}.tar.bz2;"
SRC_URI[md5sum] = "76a7a455289c9216ee0fbb8de71c9799"
SRC_URI[sha256sum] = "5e4daee61d89dfdc8c7bf369f81c99845931e337916dc6401e301c5de57ea336"
include refpolicy_common.inc
